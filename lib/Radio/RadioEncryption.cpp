#include "RadioEncryption.h"
#include <string.h>

// Note: Encryption key is provided through WeatherStationConfig.h by local-only RadioSecrets.h.

// --- Simple AES-128 ECB implementation ---
// This is a minimal, non-optimized AES implementation suitable for Arduino.
// For production, consider using a hardware AES accelerator if available.

namespace {

// AES S-box
static const uint8_t SBOX[256] = {
    0x63, 0x7c, 0x77, 0x7b, 0xf2, 0x6b, 0x6f, 0xc5, 0x30, 0x01, 0x67, 0x2b, 0xfe, 0xd7, 0xab, 0x76,
    0xca, 0x82, 0xc9, 0x7d, 0xfa, 0x59, 0x47, 0xf0, 0xad, 0xd4, 0xa2, 0xaf, 0x9c, 0xa4, 0x72, 0xc0,
    0xb7, 0xfd, 0x93, 0x26, 0x36, 0x3f, 0xf7, 0xcc, 0x34, 0xa5, 0xe5, 0xf1, 0x71, 0xd8, 0x31, 0x15,
    0x04, 0xc7, 0x23, 0xc3, 0x18, 0x96, 0x05, 0x9a, 0x07, 0x12, 0x80, 0xe2, 0xeb, 0x27, 0xb2, 0x75,
    0x09, 0x83, 0x2c, 0x1a, 0x1b, 0x6e, 0x5a, 0xa0, 0x52, 0x3b, 0xd6, 0xb3, 0x29, 0xe3, 0x2f, 0x84,
    0x53, 0xd1, 0x00, 0xed, 0x20, 0xfc, 0xb1, 0x5b, 0x6a, 0xcb, 0xbe, 0x39, 0x4a, 0x4c, 0x58, 0xcf,
    0xd0, 0xef, 0xaa, 0xfb, 0x43, 0x4d, 0x33, 0x85, 0x45, 0xf9, 0x02, 0x7f, 0x50, 0x3c, 0x9f, 0xa8,
    0x51, 0xa3, 0x40, 0x8f, 0x92, 0x9d, 0x38, 0xf5, 0xbc, 0xb6, 0xda, 0x21, 0x10, 0xff, 0xf3, 0xd2,
    0xcd, 0x0c, 0x13, 0xec, 0x5f, 0x97, 0x44, 0x17, 0xc4, 0xa7, 0x7e, 0x3d, 0x64, 0x5d, 0x19, 0x73,
    0x60, 0x81, 0x4f, 0xdc, 0x22, 0x2a, 0x90, 0x88, 0x46, 0xee, 0xb8, 0x14, 0xde, 0x5e, 0x0b, 0xdb,
    0xe0, 0x32, 0x3a, 0x0a, 0x49, 0x06, 0x24, 0x5c, 0xc2, 0xd3, 0xac, 0x62, 0x91, 0x95, 0xe4, 0x79,
    0xe7, 0xc8, 0x37, 0x6d, 0x8d, 0xd5, 0x4e, 0xa9, 0x6c, 0x56, 0xf4, 0xea, 0x65, 0x7a, 0xae, 0x08,
    0xba, 0x78, 0x25, 0x2e, 0x1c, 0xa6, 0xb4, 0xc6, 0xe8, 0xdd, 0x74, 0x1f, 0x4b, 0xbd, 0x8b, 0x8a,
    0x70, 0x3e, 0xb5, 0x66, 0x48, 0x03, 0xf6, 0x0e, 0x61, 0x35, 0x57, 0xb9, 0x86, 0xc1, 0x1d, 0x9e,
    0xe1, 0xf8, 0x98, 0x11, 0x69, 0xd9, 0x8e, 0x94, 0x9b, 0x1e, 0x87, 0xe9, 0xce, 0x55, 0x28, 0xdf,
    0x8c, 0xa1, 0x89, 0x0d, 0xbf, 0xe6, 0x42, 0x68, 0x41, 0x99, 0x2d, 0x0f, 0xb0, 0x54, 0xbb, 0x16
};

// AES inverse S-box
static const uint8_t INV_SBOX[256] = {
    0x52, 0x09, 0x6a, 0xd5, 0x30, 0x36, 0xa5, 0x38, 0xbf, 0x40, 0xa3, 0x9e, 0x81, 0xf3, 0xd7, 0xfb,
    0x7c, 0xe3, 0x39, 0x82, 0x9b, 0x2f, 0xff, 0x87, 0x34, 0x8e, 0x43, 0x44, 0xc4, 0xde, 0xe9, 0xcb,
    0x54, 0x7b, 0x94, 0x32, 0xa6, 0xc2, 0x23, 0x3d, 0xee, 0x4c, 0x95, 0x0b, 0x42, 0xfa, 0xc3, 0x4e,
    0x08, 0x2e, 0xa1, 0x66, 0x28, 0xd9, 0x24, 0xb2, 0x76, 0x5b, 0xa2, 0x49, 0x6d, 0x8b, 0xd1, 0x25,
    0x72, 0xf8, 0xf6, 0x64, 0x86, 0x68, 0x98, 0x16, 0xd4, 0xa4, 0x5c, 0xcc, 0x5d, 0x65, 0xb6, 0x92,
    0x6c, 0x70, 0x48, 0x50, 0xfd, 0xed, 0xb9, 0xda, 0x5e, 0x15, 0x46, 0x57, 0xa7, 0x8d, 0x9d, 0x84,
    0x90, 0xd8, 0xab, 0x00, 0x8c, 0xbc, 0xd3, 0x0a, 0xf7, 0xe4, 0x58, 0x05, 0xb8, 0xb3, 0x45, 0x06,
    0xd0, 0x2c, 0x1e, 0x8f, 0xca, 0x3f, 0x0f, 0x02, 0xc1, 0xaf, 0xbd, 0x03, 0x01, 0x13, 0x8a, 0x6b,
    0x3a, 0x91, 0x11, 0x41, 0x4f, 0x67, 0xdc, 0xea, 0x97, 0xf2, 0xcf, 0xce, 0xf0, 0xb4, 0xe6, 0x73,
    0x96, 0xac, 0x74, 0x22, 0xe7, 0xad, 0x35, 0x85, 0xe2, 0xf9, 0x37, 0xe8, 0x1c, 0x75, 0xdf, 0x6e,
    0x47, 0xf1, 0x1a, 0x71, 0x1d, 0x29, 0xc5, 0x89, 0x6f, 0xb7, 0x62, 0x0e, 0xaa, 0x18, 0xbe, 0x1b,
    0xfc, 0x56, 0x3e, 0x4b, 0xc6, 0xd2, 0x79, 0x20, 0x9a, 0xdb, 0xc0, 0xfe, 0x78, 0xcd, 0x5a, 0xf4,
    0x1f, 0xdd, 0xa8, 0x33, 0x88, 0x07, 0xc7, 0x31, 0xb1, 0x12, 0x10, 0x59, 0x27, 0x80, 0xec, 0x5f,
    0x60, 0x51, 0x7f, 0xa9, 0x19, 0xb5, 0x4a, 0x0d, 0x2d, 0xe5, 0x7a, 0x9f, 0x93, 0xc9, 0x9c, 0xef,
    0xa0, 0xe0, 0x3b, 0x4d, 0xae, 0x2a, 0xf5, 0xb0, 0xc8, 0xeb, 0xbb, 0x3c, 0x83, 0x53, 0x99, 0x61,
    0x17, 0x2b, 0x04, 0x7e, 0xba, 0x77, 0xd6, 0x26, 0xe1, 0x69, 0x14, 0x63, 0x55, 0x21, 0x0c, 0x7d
};

// Galois field multiplication
static uint8_t gmul(uint8_t a, uint8_t b) {
    uint8_t p = 0;
    for (int i = 0; i < 8; i++) {
        if (b & 1) p ^= a;
        uint8_t hi_bit_set = (a & 0x80);
        a <<= 1;
        if (hi_bit_set) a ^= 0x1b;
        b >>= 1;
    }
    return p;
}

// RotWord for key expansion
static void rot_word(uint8_t* w) {
    uint8_t t = w[0];
    w[0] = w[1];
    w[1] = w[2];
    w[2] = w[3];
    w[3] = t;
}

// SubWord for key expansion
static void sub_word(uint8_t* w) {
    for (int i = 0; i < 4; i++) {
        w[i] = SBOX[w[i]];
    }
}

// Key expansion for AES-128 (produces 44 round key words = 176 bytes)
static void key_expansion(const uint8_t key[16], uint8_t round_keys[176]) {
    uint8_t rcon[10] = {0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x1b, 0x36};

    // Copy original key
    memcpy(round_keys, key, 16);

    // Generate remaining round keys
    for (int i = 4; i < 44; i++) {
        uint8_t temp[4];
        memcpy(temp, &round_keys[(i - 1) * 4], 4);

        if (i % 4 == 0) {
            rot_word(temp);
            sub_word(temp);
            temp[0] ^= rcon[i / 4 - 1];
        }

        for (int j = 0; j < 4; j++) {
            round_keys[i * 4 + j] = round_keys[(i - 4) * 4 + j] ^ temp[j];
        }
    }
}

// AES-128 cipher core
static void aes_encrypt_block(uint8_t block[16], const uint8_t round_keys[176]) {
    uint8_t temp;

    // Initial round key addition
    for (int i = 0; i < 16; i++) {
        block[i] ^= round_keys[i];
    }

    // 9 main rounds
    for (int round = 1; round < 10; round++) {
        // SubBytes
        for (int i = 0; i < 16; i++) {
            block[i] = SBOX[block[i]];
        }

        // ShiftRows
        temp = block[1]; block[1] = block[5]; block[5] = block[9]; block[9] = block[13]; block[13] = temp;
        temp = block[2]; block[2] = block[10]; block[10] = temp;
        temp = block[6]; block[6] = block[14]; block[14] = temp;
        temp = block[3]; block[3] = block[15]; block[15] = block[11]; block[11] = block[7]; block[7] = temp;

        // MixColumns
        for (int i = 0; i < 16; i += 4) {
            uint8_t a0 = block[i], a1 = block[i+1], a2 = block[i+2], a3 = block[i+3];
            block[i]   = gmul(0x02, a0) ^ gmul(0x03, a1) ^ a2 ^ a3;
            block[i+1] = a0 ^ gmul(0x02, a1) ^ gmul(0x03, a2) ^ a3;
            block[i+2] = a0 ^ a1 ^ gmul(0x02, a2) ^ gmul(0x03, a3);
            block[i+3] = gmul(0x03, a0) ^ a1 ^ a2 ^ gmul(0x02, a3);
        }

        // Round key addition
        for (int i = 0; i < 16; i++) {
            block[i] ^= round_keys[round * 16 + i];
        }
    }

    // Final round (no MixColumns)
    uint8_t temp_final;
    for (int i = 0; i < 16; i++) {
        block[i] = SBOX[block[i]];
    }
    temp_final = block[1]; block[1] = block[5]; block[5] = block[9]; block[9] = block[13]; block[13] = temp_final;
    temp_final = block[2]; block[2] = block[10]; block[10] = temp_final;
    temp_final = block[6]; block[6] = block[14]; block[14] = temp_final;
    temp_final = block[3]; block[3] = block[15]; block[15] = block[11]; block[11] = block[7]; block[7] = temp_final;

    for (int i = 0; i < 16; i++) {
        block[i] ^= round_keys[10 * 16 + i];
    }
}

// AES-128 decipher core
static void aes_decrypt_block(uint8_t block[16], const uint8_t round_keys[176]) {
    uint8_t temp;

    // Initial round key addition
    for (int i = 0; i < 16; i++) {
        block[i] ^= round_keys[10 * 16 + i];
    }

    // 9 main rounds
    for (int round = 9; round > 0; round--) {
        // Inverse ShiftRows
        temp = block[13]; block[13] = block[9]; block[9] = block[5]; block[5] = block[1]; block[1] = temp;
        temp = block[10]; block[10] = block[2]; block[2] = temp;
        temp = block[14]; block[14] = block[6]; block[6] = temp;
        temp = block[3]; block[3] = block[7]; block[7] = block[11]; block[11] = block[15]; block[15] = temp;

        // InvSubBytes
        for (int i = 0; i < 16; i++) {
            block[i] = INV_SBOX[block[i]];
        }

        // Round key addition
        for (int i = 0; i < 16; i++) {
            block[i] ^= round_keys[round * 16 + i];
        }

        // InvMixColumns
        for (int i = 0; i < 16; i += 4) {
            uint8_t a0 = block[i], a1 = block[i+1], a2 = block[i+2], a3 = block[i+3];
            block[i]   = gmul(0x0e, a0) ^ gmul(0x0b, a1) ^ gmul(0x0d, a2) ^ gmul(0x09, a3);
            block[i+1] = gmul(0x09, a0) ^ gmul(0x0e, a1) ^ gmul(0x0b, a2) ^ gmul(0x0d, a3);
            block[i+2] = gmul(0x0d, a0) ^ gmul(0x09, a1) ^ gmul(0x0e, a2) ^ gmul(0x0b, a3);
            block[i+3] = gmul(0x0b, a0) ^ gmul(0x0d, a1) ^ gmul(0x09, a2) ^ gmul(0x0e, a3);
        }
    }

    // Final round (no InvMixColumns)
    uint8_t temp_final_dec;
    temp_final_dec = block[13]; block[13] = block[9]; block[9] = block[5]; block[5] = block[1]; block[1] = temp_final_dec;
    temp_final_dec = block[10]; block[10] = block[2]; block[2] = temp_final_dec;
    temp_final_dec = block[14]; block[14] = block[6]; block[6] = temp_final_dec;
    temp_final_dec = block[3]; block[3] = block[7]; block[7] = block[11]; block[11] = block[15]; block[15] = temp_final_dec;
    for (int i = 0; i < 16; i++) {
        block[i] = INV_SBOX[block[i]];
    }

    for (int i = 0; i < 16; i++) {
        block[i] ^= round_keys[i];
    }
}

} // namespace

void RadioEncryption::encrypt(const WeatherPacket& plaintext, EncryptedWeatherPacket& ciphertext) {
    uint8_t round_keys[176];
    key_expansion(ENCRYPTION_KEY, round_keys);

    // Copy plaintext (24 bytes) to buffer and pad with zeros to 32 bytes
    uint8_t buffer[32];
    memcpy(buffer, &plaintext, sizeof(WeatherPacket));
    memset(buffer + sizeof(WeatherPacket), 0, 32 - sizeof(WeatherPacket));

    // Encrypt 2 blocks (16 bytes each)
    aes_encrypt_block(&buffer[0], round_keys);
    aes_encrypt_block(&buffer[16], round_keys);

    // Copy result to ciphertext
    memcpy(&ciphertext.data[0], buffer, 32);
}

bool RadioEncryption::decrypt(const EncryptedWeatherPacket& ciphertext, WeatherPacket& plaintext) {
    uint8_t round_keys[176];
    key_expansion(ENCRYPTION_KEY, round_keys);

    // Copy ciphertext to buffer
    uint8_t buffer[32];
    memcpy(buffer, &ciphertext.data[0], 32);

    // Decrypt 2 blocks (16 bytes each)
    aes_decrypt_block(&buffer[0], round_keys);
    aes_decrypt_block(&buffer[16], round_keys);

    // Copy decrypted plaintext back
    memcpy(&plaintext, buffer, sizeof(WeatherPacket));

    return true;
}
